## build/br-ext/package/aflplusplus_ext/Config.in
```kconfig
config BR2_PACKAGE_AFLPLUSPLUS_EXT
	bool "aflplusplus"
	help
	  http://github.org/OP-TEE/optee_examples
```
